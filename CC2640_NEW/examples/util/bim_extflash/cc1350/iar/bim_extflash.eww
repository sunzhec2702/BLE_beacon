<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bim_extflash.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>bim_extflash</project>
        <configuration>FlashOnly_LP</configuration>
      </member>
      <member>
        <project>bim_extflash</project>
        <configuration>FlashOnly_ST</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


