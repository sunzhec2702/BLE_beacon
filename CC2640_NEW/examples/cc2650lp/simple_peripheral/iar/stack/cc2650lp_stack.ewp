# IAR project cc2650lp_stack.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BLE_NO_SECURITY; CC26XX; CC26XXWARE; DATA=; EXT_HAL_ASSERT; FLASH_ROM_BUILD; GATT_NO_CLIENT; INCLUDE_AES_DECRYPT; NEAR_FUNC=; OSAL_CBTIMER_NUM_TASKS=1; OSAL_SNV=1; POWER_SAVING; USE_ICALL; xDEBUG; xDEBUG_ENC; xDEBUG_GPIO; xDEBUG_SW_TRACE; xPM_DISABLE_PWRDOWN; xTESTMODES; xTEST_BLEBOARD
  ICCARM.IExtraOptions: --aeabi; -f $SRC_EX$/config/build_components.opt; -f build_config.opt
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/cm0_patch; $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_BLE_CORE$/rom; $SRC_EX$/common/cc26xx; $SRC_EX$/common/cc26xx/npi/stack; $SRC_COMMON$/hal/src/target/_common; $SRC_EX$/examples/simple_peripheral/cc26xx/stack; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/roles; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/npi/src; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/aes/cc26xx; $SRC_COMMON$/services/src/nv; $SRC_COMMON$/services/src/nv/cc26xx; $SRC_COMMON$/services/src/saddr; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_peripheral_cc2650lp_stack.hex
  prebuild: "$TOOLS_BLE$/lib_search/lib_search.exe" build_config.opt "$TOOLS_BLE$/lib_search/params_split_cc2640.xml" $SRC_BLE_CORE$/../blelib  ../config/lib_linker.cmd
  postbuild: "$TOOLS_BLE$/frontier/frontier.exe" iar "$CONFIG_NAME$/List/simple_peripheral_cc2650lp_stack.map" "../config/iar_boundary.bdef" "../config/iar_boundary.xcl"
  ILINK.IlinkOutputFile: simple_peripheral_cc2650lp_stack.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=1; CC2650=1
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_stack.icf
  ILINK.IlinkExtraOptions: -f ../config/lib_linker.cmd
  ILINK.IlinkAdditionalLibs: $ROM$/ble_rom_releases/04242014/ble_rom_patch.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: startup_entry
  group HAL/Common
    ../../../../../src/components/hal/src/common/: hal_assert.c
  group HAL/Include
    ../../../../../src/components/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    ../../../../../src/components/hal/src/target/_common/: hal_mcu.h
  group HAL/Target/CC2650/Config
    ../../../../../src/components/hal/src/target/_common/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    ../../../../../src/components/hal/src/target/_common/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group ICallBLE
    ../../../../../src/icall/stack/: ble_dispatch.c
    ../../../../../src/icall/inc/: ble_dispatch.h
  group INCLUDE
    ../../../../../src/inc/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h linkdb.h sm.h
    ../../../../../src/controller/cc26xx/inc/: ll.h
  group LIB
    ../config/: lib_linker.cmd
  group NPI
    ../../../../../src/common/cc26xx/npi/stack/: npi.c
  group OSAL
    ../../../../../src/components/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    ../../../../../src/components/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    ../../../../../src/components/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group Profiles
    ../../../../../src/profiles/roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../../../../src/host/: gattservapp_util.c sm_ecc.c
  group Startup
    ../../../../../src/icall/stack/: ble_user_config.c
    ../../../../../src/common/cc26xx/: icall_startup.c
    ../../../../../src/examples/simple_peripheral/cc26xx/stack/: osal_icall_ble.c
    ../../../../../src/rom/: rom_jt.c
  group Tools
    ../../../../../src/config/: build_components.opt
    ./: build_config.opt
    ../../../../../src/common/cc26xx/iar/: cc26xx_stack.icf
    ../../../../../src/common/cc26xx/: onboard.c onboard.h
